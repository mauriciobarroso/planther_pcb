File: mcu.kicad_sch (KiCad schematic)
At the start: 13 parts, among them J1 PROG_CNN, U1 STM32U031F8P6

Commit message: updated last changes
Other:
- moved on the sheet: C9
